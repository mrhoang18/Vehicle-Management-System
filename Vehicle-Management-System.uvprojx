# Keil uVision project Vehicle-Management-System.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_1
  c flags: OneElfS=1 uC99=1 wLevel=2
  c include: .\fatfs;.\delay;.\rc522;.\lcd;.\sdcard;.\fatfs\option
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group delay
    ./delay/: delay.c delay.h
  group rc522
    ./rc522/: rc522.c rc522.h
  group lcd
    ./lcd/: i2c-lcd.c i2c-lcd.h
  group sdcard
    ./sdcard/: fatfs.c fatfs.h fatfs_sd.c fatfs_sd.h ffconf.h user_diskio.c user_diskio.h
    ./fatfs/: ff_gen_drv.c ff_gen_drv.h ff.c ff.h diskio.c diskio.h
    ./fatfs/option/: ccsbcs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
